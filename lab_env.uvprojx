# Keil uVision project lab_env.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32_exec
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: RVDS_ARMCM3_LM3S102
  c include: ..\CORTEX_STM32F103_Keil;.\STM32F10xFWLib\inc;.\FreeRTOS\inc;.
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group System
    ./: STM32F10x.s
    ./STM32F10xFWLib/src/: stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c cortexm3_macro_rvds.s
  group Application Files
    ./: main.c setup.c pin_listener.c position_tracker.c motor.c planner.c safety.c
  group FreeRTOS files
    ./FreeRTOS/src/: heap_2.c list.c port.c queue.c tasks.c serial.c
software components: CMSIS:CORE 4.3.0
